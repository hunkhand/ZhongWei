# IAR project CapSensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072C8 ST STM32F072C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F072
  ICCARM.CCIncludePath2: ..\Source\APP\inc; ..\Source\BSP\inc; ..\Source\FWLIB\inc; ..\Source\System\OS_Cfg; ..\Source\System\uC-CPU; ..\Source\System\uC-LIB; ..\Source\System\uCOS-III\Ports; ..\Source\System\uCOS-III\Source
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CapSensor.bin
  ILINK.IlinkOutputFile: CapSensor.out
  ILINK.IlinkIcfFile: CapSensor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../Source/APP/: algorithm.c Filter.c main.c MEMS.c modbus.c modbus_ascii.c os_app_hooks.c
  group BSP
    ../Source/BSP/: AT24cxx.c bsp.c bsp_int.c Capacitive.c cstartup.c DA.c led.c MMA8652.c nvic.c PCap.c SoftwareIIC.c system_stm32f0xx.c usart.c
  group FWLib
    ../Source/FWLIB/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group uC/CPU
    ../Source/System/uC-CPU/: cpu_a.asm cpu_c.c cpu_core.c
  group uC/LIB
    ../Source/System/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS-III/Ports
    ../Source/System/uCOS-III/Ports/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../Source/System/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
